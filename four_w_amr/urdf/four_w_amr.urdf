Commit message: Update four_w_amr.urdf

File: four_w_amr/urdf/four_w_amr.urdf (robot description, URDF)
Before this commit: robot four_w_amr, 8 links, 7 joints
Joints:
- joint lidar_joint: origin xyz=-0.33522 0 0.28431 rpy=0 0 3.1416 -> xyz=-0.33522 0 0.28431 rpy=0 0 1.5708
